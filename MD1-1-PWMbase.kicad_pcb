# Repository H-goemon/MD1-1-PWMbase

## KiCad design MD1-1-PWMbase.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J1: A-Port-Out; PinHeader_2x24_P2.54mm_Vertical
J2: B-Port-Out; PinHeader_2x24_P2.54mm_Vertical
J3: C-Port-Out; PinHeader_2x24_P2.54mm_Vertical
J4: D-Port; PinHeader_2x24_P2.54mm_Vertical
J5: A-Port-Out; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J6: B-Port-Out; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J7: C-Port-Out; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J8: D-Port-Out; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J9: +BattIn
J10: +BattOut
J11: Conn_01x02_Socket; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8: 1kΩ; R_0603_1608Metric

Connections:
+3.3V: J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, J5.1, J6.1, J7.1, J8.1, J11.1
+batt: J1.9, J1.10, J1.11, J1.12, J1.13, J1.14, J1.15, J1.16, J1.17, J1.18, J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, J1.26, J1.27, J1.28, J2.9, J2.10, J2.11, J2.12, J2.13, J2.14, J2.15, J2.16, J2.17, J2.18, J2.19, J2.20, J2.21, J2.22, J2.23, J2.24, J2.25, J2.26, J2.27, J2.28, J3.9, J3.10, J3.11, J3.12, J3.13, J3.14, J3.15, J3.16, J3.17, J3.18, J3.19, J3.20, J3.21, J3.22, J3.23, J3.24, J3.25, J3.26, J3.27, J3.28, J4.9, J4.10, J4.11, J4.12, J4.13, J4.14, J4.15, J4.16, J4.17, J4.18, J4.19, J4.20, J4.21, J4.22, J4.23, J4.24, J4.25, J4.26, J4.27, J4.28
/A-Foward-In: J1.5, J1.6, J5.2, R1.1
/A-Rear-In: J1.3, J1.4, J5.3, R2.1
/B-Foward-In: J2.5, J2.6, J6.2, R3.1
/B-Rear-In: J2.3, J2.4, J6.3, R4.1
/C-Foward-In: J3.5, J3.6, J7.2, R5.1
/C-Rear-In: J3.3, J3.4, J7.3, R6.1
/D-Foward-In: J4.5, J4.6, J8.2, R7.1
/D-Rear-In: J4.3, J4.4, J8.3, R8.1
GND: J1.29, J1.30, J1.31, J1.32, J1.33, J1.34, J1.35, J1.36, J1.37, J1.38, J1.39, J1.40, J1.41, J1.42, J1.43, J1.44, J1.45, J1.46, J1.47, J1.48, J2.29, J2.30, J2.31, J2.32, J2.33, J2.34, J2.35, J2.36, J2.37, J2.38, J2.39, J2.40, J2.41, J2.42, J2.43, J2.44, J2.45, J2.46, J2.47, J2.48, J3.29, J3.30, J3.31, J3.32, J3.33, J3.34, J3.35, J3.36, J3.37, J3.38, J3.39, J3.40, J3.41, J3.42, J3.43, J3.44, J3.45, J3.46, J3.47, J3.48, J4.29, J4.30, J4.31, J4.32, J4.33, J4.34, J4.35, J4.36, J4.37, J4.38, J4.39, J4.40, J4.41, J4.42, J4.43, J4.44, J4.45, J4.46, J4.47, J4.48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
GNDSig: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.7, J1.8, J2.7, J2.8, J3.7, J3.8, J4.7, J4.8, J5.4, J6.4, J7.4, J8.4, J11.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: J9.2, J10.2

Notes on the sheet:
モタドラ⇔マザー

Board: 2 copper layers, 93.1 x 92.6 mm, 29 parts (0 on the bottom side), 20 nets.
